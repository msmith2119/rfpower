Cin in n1 10p
C1 n1 gnd 70p
L1 n1 gnd 2u
C2 n1 n2 2.2p
C3 n2 gnd 70p
L2 n2 gnd 2u
C4 n2 n3 2.2p
C5 n3 gnd 70p
L3 n3 gnd 2u
C6 n3 out 10p
